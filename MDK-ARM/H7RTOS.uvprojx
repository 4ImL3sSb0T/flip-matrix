# Keil uVision project H7RTOS.uvprojx, settings and files
target H7RTOS (6220000::V6.22::ARMCLANG)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: H7RTOS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: APPLICATION_ADDRESS=0x90000000U,USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H750xx,configCHECK_FOR_STACK_OVERFLOW=2,configAPPLICATION_ALLOCATED_HEAP=1,configGENERATE_RUN_TIME_STATS=1,configUSE_STATS_FORMATTING_FUNCTIONS=2,ARM_MATH_CM7
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../src;../Drivers/CMSIS/DSP/Include
  asm include: as above
  memory RVCT4: ROM 0x90000000 size 0x800000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c i2c.c spi.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c rtos_heap.c
  group Application/BSP
    ../src/bsp/imu963ra/: zf_device_imu963ra.c
    ../src/bsp/uart/: uart_async.c
    ../src/bsp/ws2812b/: driver_ws2812b.c driver_ws2812b_interface.c
  group Application/Service
    ../src/service/cli/: shell.c shell_ext.c shell_companion.c cpu_cmd.c
    ../src/service/cli/port/: shell_port.c
    ../src/service/cli/log/: log.c
    ../src/service/imu/: imu_service.c
    ../src/service/imu/MadgwickAHRS/: MadgwickAHRS.c
    ../src/service/matrix/: matrix.c matrix_cmd.c
    ../src/service/tools/: common_def.c vec_math.c
    ../src/service/flip/: flip_core.c
  group Application/App
    ../src/app/: app_water_sim.c app_water_sim_cmd.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
    ../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM7lfsp_math.lib
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 6.1.0
